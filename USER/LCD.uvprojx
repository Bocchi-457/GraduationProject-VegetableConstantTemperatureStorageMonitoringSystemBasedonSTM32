# Keil uVision project LCD.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LCD +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_FWLib\inc;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LCD;..\HARDWARE\AD;..\HARDWARE\DHT11;..\HARDWARE\Timer;..\HARDWARE\SIM800L;..\HARDWARE\OLED;..\HARDWARE\KEY;..\HARDWARE\SGP30;..\HARDWARE\EXIT;..\HARDWARE\STMFLASH;..\HARDWARE\Light;..\HARDWARE\Usart;..\SYSTEM\adc;..\HARDWARE\control;..\HARDWARE\DS1302;..\HARDWARE\ESP8266
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c main.c
  group HARDWARE
    ../HARDWARE/DHT11/: dht11.c dht11.h
    ../HARDWARE/Timer/: Timer.c Timer.h
    ../HARDWARE/OLED/: oled.c bmp.h oled.h oledfont.h
    ../HARDWARE/KEY/: Key.c Key.h
    ../HARDWARE/STMFLASH/: stmflash.c stmflash.h
    ../HARDWARE/Light/: Light.c Light.h
    ../HARDWARE/Usart/: Usart.c Usart.h
    ../HARDWARE/control/: control.c control.h
    ../HARDWARE/DS1302/: DS1302.c DS1302.h
    ../HARDWARE/ESP8266/: ESP8266.lib esp8266.h
    ../HARDWARE/AD/: AD.h
    ../HARDWARE/EXIT/: CountSensor.h
    ../HARDWARE/LED/: led.h
    ../HARDWARE/MQ-135/: mq135.h
    ../HARDWARE/PWM/: PWM.h
    ../HARDWARE/rtc/: MyRTC.h
    ../HARDWARE/SGP30/: SGP30.h
    ../HARDWARE/TIM/: TIM.h
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWlib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/adc/: adcx.c
